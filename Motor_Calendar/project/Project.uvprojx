# Keil uVision project Project.uvprojx, settings and files
target LSD_STM32L0_Examples (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LSD_STM32L0_Examples +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx,USE_HAL_DRIVER
  c include: ..\STM32Cube_FW_L0_V1.1.0\Drivers\CMSIS\Include;..\STM32Cube_FW_L0_V1.1.0\Drivers\CMSIS\ST;..\STM32Cube_FW_L0_V1.1.0\Drivers\STM32L0xx_HAL_Driver\Inc;..\APP;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ../APP/: main.c stm32l0xx_it.c
  group BSP
    ../BSP/: led.c rcc.c uart.c rtc.c Motor.c
  group Drivers/CMSIS
    ../STM32Cube_FW_L0_V1.1.0/Drivers/CMSIS/ST/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../STM32Cube_FW_L0_V1.1.0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group Starup
    ../STM32Cube_FW_L0_V1.1.0/Starup/: startup_stm32l053xx.s
